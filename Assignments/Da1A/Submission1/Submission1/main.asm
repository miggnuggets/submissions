;
; Submission1.asm
;
; Created: 2/8/2019 2:17:23 PM
; Author : Michael Johnson
; Design Assignment 1A

.include<m328pdef.inc>

 start:
 .ORG 00
	LDI R22, 0x05 ; 5
	LDI R23, 0x05 ; 5
	LDI R25, 0x3C ; HIGH 60
	LDI R24, 0x3C ; LOW 60
L1: ADD R19, R25 ; COLUMN 2
	DEC R22 ; R22 = R22-1
	BRCS OVERFLOW1
	BRNE L1
L2: ADD R18, R24 ; COLUMN 1
	DEC R23 ; R23 = R23-1
	BRCS OVERFLOW2
	BRNE L2
L3: RJMP L3

OVERFLOW1: SUBI R20, -1 ; CREATING CARRY FOR COLUMN 3
	CLC
	BRCS OVERFLOW3
	CPI R22,0
	BREQ L2
	RJMP L1
OVERFLOW2: SUBI R17, -1 ; CREATING CARRY FOR COLUMN 2
	CLC
	ADD R19, R17 ; ADD CARRY FROM COLUMN 1 TO COLUMN 2
	BRCS OVERFLOW3
	CPI R23, 0
	BREQ L3
	RJMP L2
OVERFLOW3: SUBI R20, -1 ; ADD CARRY INTO COLUMN 3
	CLC
	RJMP L3
